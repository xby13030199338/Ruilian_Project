# Keil uVision project Project.uvprojx, settings and files
target GD32E10X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32E103RB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103V_EVAL,USE_USB_FS
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\Drive\Inc;..\..\QRcode\Inc;..\..\Firmware\GD32E10x_usbfs_library\ustd\common;..\..\Firmware\GD32E10x_usbfs_library\driver\Include;..\..\Firmware\GD32E10x_usbfs_library\device\class\cdc\Include;..\..\Firmware\GD32E10x_usbfs_library\device\core\Include;..\..\Firmware\GD32E10x_usbfs_library\ustd\class\cdc;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32e10x_it.c gd32e10x_hw.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Peripherals
    ../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Utilities
    ../../Utilities/: gd32e10x_eval.c gd32e10x_lcd_eval.c
    ../../Utilities/LCD_Commom/: lcd_font.c
  group Doc
    ../: readme.txt
  group Drive
    ../../Drive/Src/: GUI.c ST7735.c 74HC595.c init.c W25Q16.c
  group QRCode
    ../../QRcode/Src/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group USB_Drivers
    ../../Firmware/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../Firmware/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../Firmware/GD32E10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
